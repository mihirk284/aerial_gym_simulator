Commit message: aerodynamics dump for later
Signed-off-by: Mihir Kulkarni <mihirk284@gmail.com>

File: resources/robots/quad/quad.urdf (robot description, URDF)
Before this commit: robot quadrotor, 9 links, 8 joints
Links:
- link base_link: mass 0.225 -> 1.225
